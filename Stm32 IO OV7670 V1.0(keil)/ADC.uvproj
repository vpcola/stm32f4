# Keil uVision project ADC.uvproj, settings and files
target ADC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\source;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./source/: delay.c ili9320.c SCCB.c ov7670.c main.c stm32f10x_it.c
  group FWLib
    ./source/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
