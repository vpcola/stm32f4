# IAR project STM3210E-EVAL_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\FWLib\library\inc; ..\..\..\USBLib\library\inc; ..\..\fatfs
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_ov7670_Demo.hex
  ILINK.IlinkOutputFile: STM3210E-EVAL_Demo.OUT
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FATFS
    ../../fatfs/: ccsbcs.c diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group FWLib
    ../../../FWLib/library/src/: stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../../source/: delay.c fifo.c hw_config.c ILI9331.C main.c ov7670.c sccb.c sdcard.c stm32f10x_dma.c stm32f10x_it.c
