# Keil uVision project STM32F746ZGTx.uvprojx, settings and files
target STM32F746ZGTx Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.4.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746ZGTx Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;           ../Middlewares/Third_Party/LwIP/system;           ../Middlewares/Third_Party/LwIP/src/include;           ../Middlewares/Third_Party/LwIP/src/include/ipv4;           ../Drivers/STM32F7xx_HAL_Driver/Inc;           ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;           ../Middlewares/Third_Party/FatFs/src;           ../Middlewares/Third_Party/FreeRTOS/Source/include;           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;           ../Middlewares/Third_Party/LwIP/system/arch;           ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip;           ../Middlewares/Third_Party/LwIP/src/include/lwip;           ../Middlewares/Third_Party/LwIP/src/include/netif;           ../Middlewares/Third_Party/LwIP/src/include/posix;           ../Middlewares/Third_Party/LwIP/src/include/posix/sys;           ../Middlewares/Third_Party/LwIP/src/netif/ppp;           ../Drivers/CMSIS/Include;           ../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netbuf.c tcpip.c api_lib.c netifapi.c sockets.c netdb.c err.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp.c dhcp.c dns.c init.c mem.c memp.c netif.c stats.c raw.c lwip_timers.c tcp_in.c pbuf.c udp.c tcp_out.c def.c sys.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip_frag.c inet_chksum.c ip.c inet.c igmp.c ip_addr.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: fsm.c ipcp.c magic.c ppp.c chap.c lcp.c auth.c randm.c ppp_oe.c vj.c md5.c pap.c chpms.c
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: msg_out.c mib_structs.c mib2.c msg_in.c asn1_enc.c asn1_dec.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Application/User
    ../Src/: main.c stm32f7xx_hal_msp.c ethernetif.c stm32f7xx_it.c fatfs.c lwip.c user_diskio.c freertos.c i2c.c spi.c gpio.c dcmi.c usart.c dma.c tim.c mdkretarget.c ov7670.c shell.c utility.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c croutine.c event_groups.c queue.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
software components: CMSIS:CORE 4.1.0
